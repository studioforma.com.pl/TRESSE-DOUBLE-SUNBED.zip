Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Tresse - Double Sunbed - ifc4.ifc
Time: 2023-10-10T16:36:01
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (37)
Name
 | 1_28 - ObjectType: SketchupGroup
 | 1_31 - ObjectType: SketchupGroup
 | 1_32 - ObjectType: SketchupGroup
 | 1_33 - ObjectType: SketchupGroup
 | 1_34 - ObjectType: SketchupGroup
 | 1_35 - ObjectType: SketchupGroup
 | 1_36 - ObjectType: SketchupGroup
 | 1_14 - ObjectType: SketchupGroup
 | 1_15 - ObjectType: SketchupGroup
 | 1_16 - ObjectType: SketchupGroup
 | 1_17 - ObjectType: SketchupGroup
 | 1_18 - ObjectType: SketchupGroup
 | 1_19 - ObjectType: SketchupGroup
 | 1_30 - ObjectType: SketchupGroup
 | 1_29 - ObjectType: SketchupGroup
 | 1_20 - ObjectType: SketchupGroup
 | 1_21 - ObjectType: SketchupGroup
 | 1_22 - ObjectType: SketchupGroup
 | 1_23 - ObjectType: SketchupGroup
 | 1_24 - ObjectType: SketchupGroup
 | 1_25 - ObjectType: SketchupGroup
 | 1_26 - ObjectType: SketchupGroup
 | 1_27 - ObjectType: SketchupGroup
 | 1_6 - ObjectType: SketchupGroup
 | 1_7 - ObjectType: SketchupGroup
 | 1_8 - ObjectType: SketchupGroup
 | 1_9 - ObjectType: SketchupGroup
 | 1_10 - ObjectType: SketchupGroup
 | 1_11 - ObjectType: SketchupGroup
 | 1_12 - ObjectType: SketchupGroup
 | 1_13 - ObjectType: SketchupGroup
 | 1_0 - ObjectType: SketchupGroup
 | 1_1 - ObjectType: SketchupGroup
 | 1_2 - ObjectType: SketchupGroup
 | 1_3 - ObjectType: SketchupGroup
 | 1_5 - ObjectType: SketchupGroup
 | 1_4 - ObjectType: SketchupGroup
